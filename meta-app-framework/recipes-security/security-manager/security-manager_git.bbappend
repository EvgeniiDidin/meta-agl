do_patch[depends] += "libcap:do_populate_sysroot"
APPLY = "no"
