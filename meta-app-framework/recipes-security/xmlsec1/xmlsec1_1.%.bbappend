
DEPENDS = "libtool libxml2 libxslt openssl gnutls libgcrypt"

BBCLASSEXTEND = "native nativesdk"
