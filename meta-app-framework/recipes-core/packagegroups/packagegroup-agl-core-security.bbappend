RDEPENDS_${PN} += "\
	xmlsec1 \
	cynara \
	dbus-cynara \
	security-manager \
	security-manager-policy \
    "
# temp. disabled to figure-out userid addition+sota
#	agl-users \
#
