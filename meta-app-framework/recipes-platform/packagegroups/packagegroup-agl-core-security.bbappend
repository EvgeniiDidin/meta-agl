RDEPENDS_${PN} += "\
	smack-system-setup \
	xmlsec1 \
	cynara \
	security-manager \
	security-manager-policy \
	agl-users \
    "

