
DEPENDS = "libtool libxml2 libxslt openssl"

BBCLASSEXTEND = "native nativesdk"
