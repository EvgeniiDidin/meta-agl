# This is a backport of:
# https://patchwork.openembedded.org/patch/140355/
FILESEXTRAPATHS_prepend := "${THISDIR}/tcf-agent:"
