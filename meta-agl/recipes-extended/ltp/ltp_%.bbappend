SRCREV = "149490ec2de45a5dc7a9fd2c31add615fdd4f82b"

SRC_URI = "git://github.com/linux-test-project/ltp.git"
