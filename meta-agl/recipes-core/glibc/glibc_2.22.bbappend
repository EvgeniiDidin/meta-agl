FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://arm/local-arm-futex.diff \
           "
