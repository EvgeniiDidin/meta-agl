dbus_%.bbappend