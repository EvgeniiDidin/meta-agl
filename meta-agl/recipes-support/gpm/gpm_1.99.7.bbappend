# Original src_uri n/a, Use mirror.
SRC_URI = "http://www.nico.schottelius.org/software/gpm/archives/gpm-1.99.7.tar.bz2 \
           file://no-docs.patch \
           file://processcreds.patch \
           file://eglibc-2.17.patch \
           file://init \
          "
