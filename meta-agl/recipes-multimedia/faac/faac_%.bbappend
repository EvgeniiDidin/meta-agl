FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRI_SRC += "file://0001-frontend-Fix-format-string-security-error.patch \
            file://0002-mp4v2-Define-__STRING-if-cdefs.h-does-not-exist.patch \
           "
