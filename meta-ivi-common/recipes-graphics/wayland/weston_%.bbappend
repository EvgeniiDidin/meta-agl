FILESEXTRAPATHS_prepend := ":${THISDIR}/weston-ivi-shell:"


EXTRA_OECONF_append = " --enable-ivi-shell"
