# remove the EXTRA_OECONF from the recipe to
# avoid an build error in >= YP SUMO
EXTRA_OECONF = ""
