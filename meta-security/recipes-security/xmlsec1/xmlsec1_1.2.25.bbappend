FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI += "file://remove-4-in-verify3.patch"

