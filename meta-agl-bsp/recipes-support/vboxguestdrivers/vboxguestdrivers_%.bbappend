COMPATIBLE_MACHINE = "(qemux86|qemux86-64|intel-corei7-64)"
