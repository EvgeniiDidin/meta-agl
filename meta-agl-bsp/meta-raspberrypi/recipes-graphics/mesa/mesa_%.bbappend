# enable ludicrous speed for GFX on rpi4 
PACKAGECONFIG_append_class-target = " v3d kmsro"
