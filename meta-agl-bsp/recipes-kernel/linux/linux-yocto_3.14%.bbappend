FILESEXTRAPATHS_prepend := "${THISDIR}/linux-yocto:"

SRC_URI += " file://0001-fanotify-fix-notification-of-groups-with-inode-mount.patch"
