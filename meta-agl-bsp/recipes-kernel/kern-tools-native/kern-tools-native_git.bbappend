FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://0001-merge_config.sh-add-CR-after-fragment.patch;patchdir=git \
	"

