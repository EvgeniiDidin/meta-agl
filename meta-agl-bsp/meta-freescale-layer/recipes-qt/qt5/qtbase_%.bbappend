
# Fixing Qt5.8 build breaks by overriding original patches with ours
# This will be fixed in the latest meta-freescale upstream
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

