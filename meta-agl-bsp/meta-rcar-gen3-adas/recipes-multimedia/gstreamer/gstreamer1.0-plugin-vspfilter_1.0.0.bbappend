COMPATIBLE_MACHINE = "r8a7795|r8a7796"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
