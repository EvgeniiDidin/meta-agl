RDEPENDS_${PN} += "\
    weston-bin \
"
