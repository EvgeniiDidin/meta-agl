RDEPENDS_${PN} += "\
	linux-firmware-wl18xx \
	ofono-tests \
	si-tools \
	ti-bt \
"
