# interim fix due to 
# ERROR: sg3-utils-1.42-r0 do_fetch: Fetcher failure for URL: 'http://sg.danny.cz/sg/p/sg3_utils-1.42.tgz'. Unable to fetch URL from any source.
#

SRC_URI = "https://fossies.org/linux/misc/sg3_utils-1.42.tgz"
