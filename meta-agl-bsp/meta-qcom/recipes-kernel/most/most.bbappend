FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_remove = " \
	    file://0001-src-most-net-add-skb_put_data-function.patch \
	   "
