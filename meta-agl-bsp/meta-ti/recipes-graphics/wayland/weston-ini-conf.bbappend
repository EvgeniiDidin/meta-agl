DEFAULT_SCREEN[name] = "UNNAMED-1"
