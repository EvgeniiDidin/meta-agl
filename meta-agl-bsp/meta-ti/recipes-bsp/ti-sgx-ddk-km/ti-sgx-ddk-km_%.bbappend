FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://add-AGL-toolchain-config.patch"
SRCREV = "16961a3f4524b653fba99d949d6972c77c7d2701"
