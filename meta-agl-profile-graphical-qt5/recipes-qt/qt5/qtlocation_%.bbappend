# Need to explicitly enable the various plugins
PACKAGECONFIG += " \
	geoservices_osm \
	geoservices_here \
	geoservices_itemsoverlay \
	geoservices_mapbox \
	geoservices_mapboxgl \
"
