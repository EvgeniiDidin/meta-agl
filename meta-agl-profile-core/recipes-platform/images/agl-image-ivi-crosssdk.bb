# just for backward compatibility
require agl-image-minimal-crosssdk.bb
