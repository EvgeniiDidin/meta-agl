FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-Enable-using-epoll-without-listen-socket_${PV}.patch"
